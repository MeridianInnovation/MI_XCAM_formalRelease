# Keil uVision project MI_XCAM_M480.uvproj, settings and files
target USBD_UVC_HTAP32 (ARM-ADS)
  device: M487JIDAE Nuvoton
  cpu: IRAM(0x20000000-0x20027FFF) IROM(0-0x7FFFF) CLOCK(50000000) CPUTYPE("Cortex-M4") FPU2
  output: MI_XCAM_M480
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 wLevel=2
  c define: MCU=480
  c include: ..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\M480\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\ThermalAPI_inC\inc;..\..\USBD_UVC_HTPA32_R1_32x32_UART;..\..\..\..\..\MI_Sensor
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x28000
  link misc: --map --first='startup_M480.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M480/Source/: system_M480.c
    ../../../../Library/Device/Nuvoton/M480/Source/ARM/: startup_M480.s
  group User
    ../: main.c descriptors.c usbd_video.c Table_UVC.c HUART.c thermal_i2c.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c retarget.c sys.c i2c.c timer.c uart.c hsusbd.c
    ../../../../Library/ThermalAPI_inC/KEIL/obj/: ThermalSensorAPI_M480.lib
