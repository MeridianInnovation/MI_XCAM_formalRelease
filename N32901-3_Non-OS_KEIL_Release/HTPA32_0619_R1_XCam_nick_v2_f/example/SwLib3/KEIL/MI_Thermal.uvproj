# Keil uVision project MI_Thermal.uvproj, settings and files
target N32901_SW_I2C (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: MI_XCAM_N329_SW_I2C
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: MCU=329
  c include: ..\..\..\lib;..\..\..\..\SYSLIB\Lib;..\..\..\..\I2C\lib;..\..\..\..\UDC\lib;..\..\..\..\VPOST\Lib;..\I2CS;..\..\..\..\ThermalAPI_inC\example\demo\KEIL;..\..\..\..\..\MI_Sensor
  asm define: N32901
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32901\N32901.sct
  link misc: --entry 0
  group Lib
    ../../../../UDC/lib/: w55fa93_UDC.lib
    ../../../../SYSLIB/Lib/: W55FA93_syslib.lib
    ../../../../VPOST/Lib/: W55FA93_VPOST.lib
    ../../../lib/: w55fa93_UVC_YUV_Only.lib
    ../../../../ThermalAPI_inC/example/demo/KEIL/demo_Data/N32901_SingleTask/: ThermalSensorAPI_N329.lib
    ../I2CS/: DrvI2C_Thermal.c
  group Source
    ../: Table_UVC.c wb_init.s main.c usbd_video.c standalone.c
